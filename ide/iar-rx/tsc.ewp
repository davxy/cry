# IAR project tsc.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: RX600 Generic RX600
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCIncludePath2: ..\..\include; ..\..\src
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: tsc.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (RX)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  group crypto
    ../../src/crypto/: tsc_aes.c tsc_aes2.c tsc_cbc.c tsc_cmac.c tsc_ctr.c tsc_ecdsa.c tsc_gcm.c
  group ec
    ../../src/ec/: tsc_ec_keygen.c tsc_ec_nist_p256.c tsc_ec_point_add.c tsc_ec_point_dbl.c tsc_ec_point_mul.c
  group md
    ../../src/md/: tsc_md5.c tsc_sha256.c
  group misc
    ../../src/misc/: tsc_memxor.c tsc_memxor.h tsc_misc.h
  group mpi
    ../../src/mpi/: tsc_mpi_add.c tsc_mpi_add_abs.c tsc_mpi_cmp.c tsc_mpi_cmp_abs.c tsc_mpi_core.c tsc_mpi_div.c tsc_mpi_div_abs.c tsc_mpi_extra.c tsc_mpi_init_bin.c tsc_mpi_init_str.c tsc_mpi_inv.c tsc_mpi_mul.c tsc_mpi_print.c tsc_mpi_pvt.h tsc_mpi_rand.c tsc_mpi_shl.c tsc_mpi_shr.c tsc_mpi_sub.c tsc_mpi_sub_abs.c
  group rand
    ../../src/rand/: tsc_rand_dummy.c
  group sum
    ../../src/sum/: tsc_crc16.c tsc_crc16_mb.c tsc_lrc.c
