# IAR project cry.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: RX600-rxv2 Generic RX600-RXv2
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x0
  ICCRX.CCIncludePath2: ..\..\include; ..\..\src
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: cry.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (RX)
  as the first configuration, except:
  General.HeapSize: 0x400
  ICCRX.CCDefines: NDEBUG
  ICCRX.CCIncludePath2: ..\..\src; ..\..\include
  group (top)
    ../../src/: misc.c misc.h version.c
  group crypto
    ../../src/crypt/: aes.c affine.c base64.c cbc.c cfb.c cmac.c ctr.c des.c dh.c dsa.c ecdh.c ecdsa.c gcm.c hill.c hmac.c memxor.c memxor.h trivium.c
  group ecp
    ../../src/ecp/: ec_nist_p256.c ecp_add.c ecp_copy.c ecp_dbl.c ecp_mul.c
  group hash
    ../../src/hash/: md5.c sha256.c
  group mpi
    ../../src/mpi/: mpi_abs.c mpi_add.c mpi_add_abs.c mpi_bin.c mpi_cmp.c mpi_cmp_abs.c mpi_core.c mpi_div.c mpi_div_abs.c mpi_exp.c mpi_gcd.c mpi_inv.c mpi_lcm.c mpi_list.c mpi_mod_exp.c mpi_mul.c mpi_mul_abs.c mpi_mul_baseline.c mpi_mul_comba.c mpi_mul_karatsuba.c mpi_mul_toom3.c mpi_prime.c mpi_pvt.h mpi_rand.c mpi_shl.c mpi_shr.c mpi_sqr.c mpi_sqrt.c mpi_str.c mpi_sub.c mpi_sub_abs.c
  group prng
    ../../src/prng/: prng_aes.c
  group sum
    ../../src/sum/: crc16.c crc16_ccitt.c crc16_dnp.c crc16_ibm.c crc32.c crc32_eth.c cs8.c lrc.c
